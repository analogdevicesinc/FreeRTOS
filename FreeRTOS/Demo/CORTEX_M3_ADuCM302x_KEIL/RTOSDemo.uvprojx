# Keil uVision project RTOSDemo.uvprojx, settings and files
target Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;C:\Keil_v5\ARM\PACK\AnalogDevices\ADuCM302x_DFP\1.0.2\Include;C:\Keil_v5\ARM\PACK\AnalogDevices\ADuCM302x_DFP\1.0.2\Include\ssdd_common;..\Common\include;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM3
  asm include: .\Include;.\FreeRTOS\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\RTOSDemo.sct
  group src
    ./src/: main.c ParTest.c
  group Standard_Demo
    ../Common/Minimal/: BlockQ.c death.c PollQ.c recmutex.c flash.c StaticAllocation.c
  group FreeRTOS
    ../../Source/: timers.c list.c queue.c tasks.c event_groups.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
  group Include
    ./Include/: adi_global_config.h FreeRTOSConfig.h user_rtos_support.h
target Release (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.1.0.4
  cpu: as above
  output: RTOSDemo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm include: .\Include;.\FreeRTOS\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\RTOSDemo.sct
software components: CMSIS:CORE 4.3.0, Device:Drivers:UART 1.0.0, Device:Examples Support 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget 1.0.0, Device:Services:DMA 1.0.0, Device:Services:GPIO 1.0.0, Device:Services:Power 1.0.0, Device:Services:WDT 1.0.0, Device:Startup 1.0.0
