# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DISABLE_INSTRUCTION_SRAM; ENABLE_CACHE; __ADUCM4050__
  ICCARM.CCIncludePath2: ..\Include\; $_ADI_CM4X50_BSP_PATH_$\Include; $_ADI_CM4X50_BSP_PATH_$\Include\config; ..\..\..\Source\include; ..\..\..\Source\portable\IAR\ARM_CM4F; ..\..\..\Demo\Common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $_ADI_CM4X50_BSP_PATH_$\Include; ..\Include
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: ..\ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ADI_DISABLE_INSTRUCTION_SRAM; ENABLE_CACHE; __ADUCM4050__
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS/portable/MemMang
    ../../../Source/portable/MemMang/: heap_4.c
  group Include
    ../Include/: adi_global_config.h FreeRTOSConfig.h
  group Library/drivers/gpio
    $_ADI_CM4X50_BSP_PATH_$/Source/drivers/gpio/: adi_gpio.c
  group Library/drivers/pwr
    $_ADI_CM4X50_BSP_PATH_$/Source/drivers/pwr/: adi_pwr.c
  group Library/system
    $_ADI_CM4X50_BSP_PATH_$/Source/: common.c system_ADuCM4050.c
    $_ADI_CM4X50_BSP_PATH_$/Source/IAR/: startup_ADuCM4050.s
  group src
    ../src/: main.c ParTest.c
  group Standard_Demo
    ../../Common/Minimal/: BlockQ.c death.c flash.c PollQ.c recmutex.c StaticAllocation.c
