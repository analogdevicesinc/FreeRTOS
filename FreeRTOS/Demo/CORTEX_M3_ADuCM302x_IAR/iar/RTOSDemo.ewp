# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_CFG_ENABLE_RTOS_SUPPORT; USER_SPECIFIED_RTOS; ADI_DISABLE_INSTRUCTION_SRAM; ENABLE_CACHE
  ICCARM.CCIncludePath2: ..\Include; ..\src; $_ADI_CM302X_BSP_PATH_$\inc; $_ADI_CM302X_BSP_PATH_$\inc\config; ..\..\..\Source\include; ..\..\..\Source\portable\IAR\ARM_CM3; ..\..\..\Demo\Common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Include
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: ..\icf\ADuCM3029.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ADI_CFG_ENABLE_RTOS_SUPPORT; USER_SPECIFIED_RTOS; ADI_DISABLE_INSTRUCTION_SRAM; ENABLE_CACHE
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS/portable/MemMang
    ../../../Source/portable/MemMang/: heap_4.c
  group Include
    ../Include/: adi_global_config.h FreeRTOSConfig.h user_rtos_support.h
  group Library/service/gpio
    $_ADI_CM302X_BSP_PATH_$/src/services/gpio/: adi_gpio.c adi_gpio_def_v1.h
  group Library/service/wdt
    $_ADI_CM302X_BSP_PATH_$/src/services/wdt/: adi_wdt.c adi_wdt_def_v1.h
  group Library/system
    $_ADI_CM302X_BSP_PATH_$/src/: common.c startup.c system.c
  group src
    ../src/: main.c ParTest.c
  group Standard_Demo
    ../../Common/Minimal/: BlockQ.c death.c flash.c PollQ.c recmutex.c StaticAllocation.c
