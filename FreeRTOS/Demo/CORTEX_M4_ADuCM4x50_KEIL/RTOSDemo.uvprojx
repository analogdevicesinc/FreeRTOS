# Keil uVision project RTOSDemo.uvprojx, settings and files
target Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;C:\Keil_v5\ARM\PACK\AnalogDevices\ADuCM4x50_DFP\1.0.0\Include;..\Common\include;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F
  asm include: .\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  scatter file: .\RTOSDemo.sct
  group src
    ./src/: main.c ParTest.c
  group Standard_Demo
    ../Common/Minimal/: BlockQ.c death.c PollQ.c recmutex.c flash.c StaticAllocation.c
  group FreeRTOS
    ../../Source/: timers.c list.c queue.c tasks.c event_groups.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM4F/: port.c
  group Include
    ./Include/: adi_global_config.h FreeRTOSConfig.h
target Release (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: as above
  output: RTOSDemo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm include: .\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  scatter file: .\RTOSDemo.sct
software components: CMSIS:CORE 4.3.0, Device:Drivers:DMA 1.0.0, Device:Drivers:GPIO 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:UART 1.0.0, Device:Drivers:WDT 1.0.0, Device:Examples Support 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget_UART 1.0.0, Device:Startup 1.0.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0
