# IAR project FreeRTOS_CMSIS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: FreeRTOS_CMSIS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main_cmsis.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADSP-SC839W/: ADSP-SC83x-2MB.icf startup_ADSP-SC83x.c system_ADSP-SC83x.c system_ADSP-SC83x.h
  group CMSIS-Pack/CMSIS.RTOS2.FreeRTOS Cortex-M
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c os_systick.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Timers_10.5.1
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/Source/: timers.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Heap.Heap_4_10.5.1
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/Source/portable/MemMang/: heap_4.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Event Groups_10.5.1
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/Source/: event_groups.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Core.Cortex-M_10.5.1
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/CMSIS/RTOS2/FreeRTOS/Source/: freertos_evr.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/Source/: list.c queue.c tasks.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#10.5.1}$/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Config.CMSIS RTOS2_10.5.1
    RTE/RTOS/: FreeRTOSConfig.h
