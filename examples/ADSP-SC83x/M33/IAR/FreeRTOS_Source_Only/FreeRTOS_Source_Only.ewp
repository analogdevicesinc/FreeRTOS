# IAR project FreeRTOS_Source_Only.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; FreeRTOS\include
  OBJCOPY.OOCOutputFile: FreeRTOS_Source_Only.srec
  ILINK.IlinkOutputFile: FreeRTOS_Source_Only.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  group (top)
    FreeRTOS/include/: FreeRTOSConfig.h
    ./: handlers.c main_source_only.c
  group FreeRTOS
    FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    FreeRTOS/portable/: heap_4.c
    FreeRTOS/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADSP-SC839W/: ADSP-SC83x-2MB.icf startup_ADSP-SC83x.c system_ADSP-SC83x.c system_ADSP-SC83x.h
